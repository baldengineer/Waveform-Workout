/* SPDX-License-Identifier: MIT */
#include "outputs.h"
#include <zephyr/drivers/dac.h>
#include <zephyr/drivers/dma.h>
#include <zephyr/drivers/gpio.h>
#include <zephyr/drivers/pinctrl.h>
#include <zephyr/kernel.h>
#include <stm32_ll_bus.h>
#include <stm32_ll_dac.h>
#include <stm32_ll_tim.h>

#define USER DT_PATH(zephyr_user)
#define DAC_NODE DT_NODELABEL(dac1)
#define MARKER_TIMER DT_NODELABEL(timers2)
#define TIMER_HZ DT_PROP(DT_NODELABEL(rcc), clock_frequency)
BUILD_ASSERT(DT_PROP(DT_NODELABEL(rcc), apb1_prescaler) == 1 &&
	     DT_PROP(DT_NODELABEL(rcc), apb2_prescaler) == 1);
BUILD_ASSERT(TIMER_HZ % 1000000 == 0 && TIMER_HZ % (10000 * CYCLE_SAMPLES) == 0);

static const struct gpio_dt_spec selectors[] = {
	GPIO_DT_SPEC_GET(USER, a_select_gpios), GPIO_DT_SPEC_GET(USER, b_select_gpios)
};
static const struct dac_dt_spec dac_a = DAC_DT_SPEC_GET_BY_NAME(USER, dac_a);
static const struct dac_dt_spec dac_b = DAC_DT_SPEC_GET_BY_NAME(USER, dac_b);
PINCTRL_DT_DEFINE(DT_NODELABEL(pwm_a));
PINCTRL_DT_DEFINE(DT_NODELABEL(pwm_b));

struct dma_stream {
	const struct device *device;
	uint8_t channel;
	uint8_t slot;
};
#define DMA_STREAM(node, name) { DEVICE_DT_GET(DT_DMAS_CTLR_BY_NAME(node, name)), \
	DT_DMAS_CELL_BY_NAME(node, name, channel), DT_DMAS_CELL_BY_NAME(node, name, slot) }
static const struct dma_stream analog = DMA_STREAM(DAC_NODE, dual);
static const struct dma_stream pulse = DMA_STREAM(MARKER_TIMER, pulse);
static const struct dma_stream marker = DMA_STREAM(MARKER_TIMER, marker);

static uint32_t samples[CYCLE_SAMPLES];
static uint16_t pulse_us[RARE_PERIODS], marker_us[RARE_PERIODS];

static int start_dma(const struct dma_stream *stream, const void *table, unsigned int count,
		     size_t width, volatile uint32_t *destination)
{
	struct dma_block_config block = {
		.source_address = (uintptr_t)table, .dest_address = (uintptr_t)destination,
		.source_addr_adj = DMA_ADDR_ADJ_INCREMENT, .dest_addr_adj = DMA_ADDR_ADJ_NO_CHANGE,
		.source_reload_en = true, .dest_reload_en = true, .block_size = count * width,
	};
	struct dma_config config = {
		.dma_slot = stream->slot, .channel_direction = MEMORY_TO_PERIPHERAL,
		.channel_priority = 2, .cyclic = true, .block_count = 1, .head_block = &block,
		.source_data_size = width, .dest_data_size = width,
		.source_burst_length = 1, .dest_burst_length = 1,
	};
	int rc = dma_config(stream->device, stream->channel, &config);
	return rc ? rc : dma_start(stream->device, stream->channel);
}

static int select_analog(bool enable)
{
	for (size_t i = 0; i < ARRAY_SIZE(selectors); ++i) {
		int rc = gpio_pin_set_dt(&selectors[i], enable);
		if (rc) {
			return rc;
		}
	}
	return 0;
}

void outputs_idle(void)
{
	TIM6->CR1 = 0;
	DAC1->CR &= ~DAC_CR_DMAEN1;
	TIM2->DIER = 0;
	TIM2->CR1 = 0;
	TIM21->CR1 = 0;
	dma_stop(analog.device, analog.channel);
	dma_stop(pulse.device, pulse.channel);
	dma_stop(marker.device, marker.channel);

	/* Latch zero duty on both digital paths before routing to them. */
	TIM2->CCR2 = 0;
	TIM21->CCR1 = 0;
	TIM2->EGR = TIM_EGR_UG;
	TIM21->EGR = TIM_EGR_UG;
	select_analog(false);
}

int outputs_init(void)
{
	for (size_t i = 0; i < ARRAY_SIZE(selectors); ++i) {
		if (!gpio_is_ready_dt(&selectors[i])) {
			return -ENODEV;
		}
		int rc = gpio_pin_configure_dt(&selectors[i], GPIO_OUTPUT_INACTIVE);
		if (rc) {
			return rc;
		}
	}
	if (!dac_is_ready_dt(&dac_a) || !dac_is_ready_dt(&dac_b) ||
	    !device_is_ready(analog.device)) {
		return -ENODEV;
	}
	int rc = dac_channel_setup_dt(&dac_a);
	if (rc) {
		return rc;
	}
	rc = dac_channel_setup_dt(&dac_b);
	if (rc) {
		return rc;
	}

	LL_APB1_GRP1_EnableClock(LL_APB1_GRP1_PERIPH_TIM6 | LL_APB1_GRP1_PERIPH_TIM2);
	LL_APB2_GRP1_EnableClock(LL_APB2_GRP1_PERIPH_TIM21);
	LL_TIM_SetTriggerOutput(TIM6, LL_TIM_TRGO_UPDATE);
	DAC1->CR |= DAC_CR_TEN1 | DAC_CR_TEN2; /* TSEL = 0 on both: TIM6 TRGO */

	/* 1 us ticks on both counters. TIM2 CEN starts TIM21 through ITR0
	 * (RM0376 table 95). PWM edges are generated by the compare units.
	 */
	TIM2->PSC = TIM21->PSC = TIMER_HZ / 1000000 - 1;
	TIM2->ARR = TIM21->ARR = TRIGGER_PERIOD_US - 1;
	LL_TIM_SetTriggerOutput(TIM2, LL_TIM_TRGO_ENABLE);
	LL_TIM_SetTriggerInput(TIM21, LL_TIM_TS_ITR0);
	LL_TIM_SetSlaveMode(TIM21, LL_TIM_SLAVEMODE_TRIGGER);
	LL_TIM_OC_SetMode(TIM2, LL_TIM_CHANNEL_CH2, LL_TIM_OCMODE_PWM1);
	LL_TIM_OC_SetMode(TIM21, LL_TIM_CHANNEL_CH1, LL_TIM_OCMODE_PWM1);
	LL_TIM_OC_EnablePreload(TIM2, LL_TIM_CHANNEL_CH2);
	LL_TIM_OC_EnablePreload(TIM21, LL_TIM_CHANNEL_CH1);
	TIM2->CCR3 = TIM2->CCR4 = TRIGGER_PERIOD_US / 2;
	/* Only CH2 is muxed to a pad. CH3 and CH4 are internal DMA clocks. */
	TIM2->CCER = TIM_CCER_CC2E | TIM_CCER_CC3E | TIM_CCER_CC4E;
	TIM21->CCER = TIM_CCER_CC1E;
	outputs_idle();
	rc = pinctrl_apply_state(PINCTRL_DT_DEV_CONFIG_GET(DT_NODELABEL(pwm_a)),
				 PINCTRL_STATE_DEFAULT);
	if (rc) {
		return rc;
	}
	return pinctrl_apply_state(PINCTRL_DT_DEV_CONFIG_GET(DT_NODELABEL(pwm_b)),
				   PINCTRL_STATE_DEFAULT);
}

static int start_trigger(uint8_t value)
{
	unsigned int count = trigger_sequence(value, pulse_us, marker_us);
	int rc = start_dma(&pulse, pulse_us, count, sizeof(*pulse_us), &TIM21->CCR1);
	if (rc) {
		return rc;
	}
	rc = start_dma(&marker, marker_us, count, sizeof(*marker_us), &TIM2->CCR2);
	if (rc) {
		return rc;
	}
	/* Begin with one quiet period. Two internal compares preload the next
	 * widths 50 us before both PWM counters roll over. No per-edge ISR.
	 */
	TIM2->SR = 0;
	TIM2->DIER = TIM_DIER_CC3DE | TIM_DIER_CC4DE;
	LL_TIM_EnableCounter(TIM2);
	return 0;
}

static int start_analog(const struct lesson *lesson)
{
	unsigned int count = CYCLE_SAMPLES;
	unsigned int rate = lesson_sample_rate(lesson);
	bool playback = lesson->mode != DC;
	if (IS_ENABLED(CONFIG_WORKOUT_FILTER_TEST)) {
		/* The DMA table starts with phase 1. Phase 0 is primed below. */
		static const uint16_t codes[] = {1457, 1457, 324, 324};
		count = ARRAY_SIZE(codes);
		rate = 1000000;
		for (unsigned int i = 0; i < count; ++i) {
			uint32_t code = codes[(i + 1) % count];
			samples[i] = (code << 16) | code;
		}
	} else {
		count = playback ? CYCLE_SAMPLES : 1;
		for (unsigned int i = 0; i < count; ++i) {
			samples[i] = lesson_sample(lesson, (i + 1) % count, dac_a.vref_mv);
		}
	}
	TIM6->ARR = TIMER_HZ / rate - 1;
	DAC1->SR = DAC_SR_DMAUDR1;
	DAC1->DHR12RD = samples[count - 1];
	if (playback) {
		int rc = start_dma(&analog, samples, count, sizeof(*samples), &DAC1->DHR12RD);
		if (rc) {
			return rc;
		}
		DAC1->CR |= DAC_CR_DMAEN1;
	}
	TIM6->EGR = TIM_EGR_UG; /* Latch phase 0; DMA stages phase 1. */
	k_busy_wait(50); /* DAC startup and external filter settling, verify at TP22/23. */
	int rc = select_analog(true);
	if (!rc && playback) {
		LL_TIM_EnableCounter(TIM6);
	}
	return rc;
}

int outputs_apply(const struct lesson *lesson)
{
	outputs_idle();
	int rc = lesson->mode == TRIG ? start_trigger(lesson->value[TRIG]) : start_analog(lesson);
	if (rc) {
		outputs_idle();
	}
	return rc;
}
